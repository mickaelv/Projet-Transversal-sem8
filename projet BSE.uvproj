# Keil uVision project projet BSE.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: projet BSE
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LIB_UART0.c LIB_UART1.c main_mika.c c8051F020.h LIB_UART0.h LIB_UART1.h Ports_Declarations.h VarGlobales_Define.h mesure_distance.c servo.c ADC1_Init.c conversion_metre.c
